# Keil uVision project gsms3.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gsms3
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app_main.c processing.c utils.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group bno055_driver
    ./bno055_driver/: bno055.c
  group neom9n_driver
    ./neom9n_driver/: neom9n.cpp ublox.cpp
  group tm_stm32
    ./tm_stm32/: tm_stm32_usart.c tm_stm32_gpio.c tm_stm32_buffer.c
software components: CMSIS:CORE 5.4.0, Board Support:LED 1.0.0, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
